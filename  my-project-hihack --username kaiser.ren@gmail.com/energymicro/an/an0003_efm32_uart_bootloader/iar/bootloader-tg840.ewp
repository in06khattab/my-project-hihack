# IAR project bootloader-tg840.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32; NDEBUG; SIZE_TAILOR=1
  ICCARM.CCIncludePath2: ..\..\..\emlib\inc; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\tg840; ..\common; ..\common\config_tg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\src; ..\src\config_tg
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\iar_linker_files\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\emlib\inc; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\tg840; ..\tg840\config_tg
  ICCARM.CCOptLevel: 3
  group (top)
    ../iar_linker_files/: EFM32TG840F32.icf
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Common
    ../common/: autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
  group Driver
    ../common/: decode.c decode.h encode.c encode.h
  group emlib
    ../../../emlib/src/: em_cmu.c
