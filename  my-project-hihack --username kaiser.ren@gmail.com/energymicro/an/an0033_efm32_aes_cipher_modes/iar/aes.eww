<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\aes_cbc_128_dma_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_cbc_128_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_ecb_128_tg.ewp</path>
  </project>
  <batchBuild/>
</workspace>


