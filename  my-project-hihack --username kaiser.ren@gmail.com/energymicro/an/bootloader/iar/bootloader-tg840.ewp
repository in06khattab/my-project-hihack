# IAR project bootloader-tg840.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32; SIZE_TAILOR=1; NDEBUG; XMODEM=0
  ICCARM.CCIncludePath2: ..\..\..\emlib\inc; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\kits\common\bsp; ..\..\..\kits\EFM32TG_STK3300\config; ..\tg840; ..\common; ..\common\config_tg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\src; ..\src\config_tg
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\iar_linker_files\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\emlib\inc; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\tg840; ..\common; ..\common\config_tg
  ICCARM.CCOptLevel: 3
  group (top)
    ../iar_linker_files/: EFM32TG840F32.icf
  group BSP
    ../../../kits/common/bsp/: bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Common
    ../common/: autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
  group Driver
    ../common/: decode.c decode.h encode.c encode.h
  group emlib
    ../../../emlib/src/: em_acmp.c em_cmu.c em_emu.c em_gpio.c em_int.c em_msc.c em_prs.c em_rmu.c em_timer.c
