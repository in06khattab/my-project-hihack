# IAR project bootloader-tg210.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 EnergyMicro EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG210F32; NDEBUG; SIZE_TAILOR=1
  ICCARM.CCIncludePath2: ..\..\..\emlib\inc; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\kits\common\bsp; ..\..\..\kits\EFM32TG_STK3300\config; ..\tg210; ..\common; ..\common\config_tg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\src; ..\src\config_tg
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\iar_linker_files\EFM32TG210F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32TG210F8 EnergyMicro EFM32TG210F8
  ICCARM.CCDefines: NDEBUG; EFM32TG210F32; SIZE_TAILOR=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group BSP
    ../../../kits/common/bsp/: bsp_stk.c bsp_stk_leds.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Common
    ../common/: autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
  group Driver
    ../common/: decode.c decode.h encode.c encode.h
  group emlib
    ../../../emlib/src/: em_acmp.c em_cmu.c em_emu.c em_gpio.c em_int.c em_prs.c em_rmu.c em_timer.c
