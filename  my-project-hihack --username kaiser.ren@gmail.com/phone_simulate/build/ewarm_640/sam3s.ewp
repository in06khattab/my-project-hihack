# IAR project sam3s.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam4s-ek; ../../../../libraries/libchip_sam4s
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: phone_simulate_sam3s.out
configuration flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: sam3s4; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../libboard_sam3s-ek; ../../libchip_sam3s; ../../libboard_sam3s-ek/include; ../../libboard_sam3s-ek/resource; ../../libchip_sam3s/include; ../../libchip_sam3s/source; ../../libboard_sam3s-ek/source
  ICCARM.CCOptLevel: 0
  AARM.ADefines: __SAM4S16C__; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../resource/sam3s4c/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group inc
    ../../: com.h decode.h encode.h irq.h main.h
  group libraries
    ../../libboard_sam3s-ek/lib/: libboard_sam3s_ek_ewarm_dbg.a
    ../../libchip_sam3s/lib/: libchip_sam3s4_ewarm_dbg.a
  group src
    ../../: com.c decode.c encode.c irq.c main.c
