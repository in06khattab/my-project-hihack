# IAR project phone_simulate_sam3s.ewp, settings and files
configuration sram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  ICCARM.CCDefines: sam3s4; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam3s-ek; ../../../../libraries/libchip_sam3s
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: sam3s4; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sam3s-ek/resources/ewarm/sam3s4/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: sam3s4; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../libboard_sam3s-ek; ../../libchip_sam3s; ../../libboard_sam3s-ek/include; ../../libboard_sam3s-ek/resource; ../../libchip_sam3s/cmsis; ../../libchip_sam3s/include; ../../libchip_sam3s/source; ../../libboard_sam3s-ek/source
  ICCARM.CCOptLevel: 0
  AARM.ADefines: sam3s4; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.hex
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: flash.icf
  group (top)
    ../../: decode.c encode.c main.c
  group libraries
    ../../libboard_sam3s-ek/lib/: libboard_sam3s_ek_ewarm_dbg.a
    ../../libchip_sam3s/lib/: libchip_sam3s4_ewarm_dbg.a
  group resources
    ./: flash.icf sram.icf
