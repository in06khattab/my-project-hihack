<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader-tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-tg-small.ewp</path>
  </project>
  <batchBuild/>
</workspace>


