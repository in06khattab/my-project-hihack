# IAR project bootloader-tg210.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 EnergyMicro EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG210F32; NDEBUG; SIZE_TAILOR=1
  ICCARM.CCIncludePath2: ..\..\..\emlib\inc; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\common; ..\common\config_tg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\src; ..\src\config_tg
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\iar_linker_files\EFM32TG210F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32TG210F8 EnergyMicro EFM32TG210F8
  ICCARM.CCDefines: NDEBUG; EFM32TG210F32
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\tg210; ..\tg210\config_tg
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Common
    ../common/: autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
  group emlib
    ../../../emlib/src/: em_cmu.c
