# IAR project ATTiny.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1281 ATmega1281
  ICCAVR.CCDefines: DEBUG=0; FFD; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB; UART1; TAL_TYPE=AT86RF212; PAL_TYPE=ATMEGA1281; PAL_GENERIC_TYPE=AVR; BOARD_TYPE=ATZB_900_MN2; HIGHEST_STACK_LAYER=PAL
  ICCAVR.newCCIncludePaths: ..\Inc; ; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\TFA\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\AVR\Generic\Inc; ..\..\..\..\PAL\AVR\ATMEGA1281\Inc; ..\..\..\..\PAL\AVR\ATMEGA1281\Boards; ..\..\..\..\PAL\AVR\ATMEGA1281\Boards\ATZB_900_MN2; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1281.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  General.SCRStackSize: 40
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_nomul-n.h
  General.GenDeviceSelectMenu: tiny87 ATtiny87
  ICCAVR.CCDefines: DEBUG=0; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB; UART1; TAL_TYPE=AT86RF212; PAL_TYPE=ATTINY88; PAL_GENERIC_TYPE=AVR; BOARD_TYPE=ATZB_900_MN2; HIGHEST_STACK_LAYER=PAL
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XExtraOptions: -Omotorola-s28=.srec
  group (top)
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group Application
    ../Src/: decode.c encode.c hal.c main.c timer.c
  group Inc
    ../Inc/: app_config.h decode.h encode.h hal.h timer.h
  group PAL
    ../../../../PAL/AVR/ATMEGA1281/Src/: pal_sio_hub.c
    ../../../../PAL/AVR/Generic/Src/: pal_uart.c pal_utils.c
  group PAL/Board
    ../../../../PAL/AVR/ATMEGA1281/Boards/ATZB_900_MN2/: pal_board.c
