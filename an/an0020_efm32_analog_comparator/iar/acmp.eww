<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\acmp_conf_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\acmp_int_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\acmp_window_tg.ewp</path>
  </project>
  <batchBuild/>
</workspace>


