# IAR project sam4s.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam4s-ek; ../../../../libraries/libchip_sam4s
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SAM4S16C__; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../libboard_sam4s-ek; ../../libchip_sam4s; ../../libboard_sam4s-ek/include; ../../libboard_sam4s-ek/resource; ../../libchip_sam4s/cmsis; ../../libchip_sam4s/include; ../../libchip_sam4s/source; ../../libboard_sam4s-ek/source
  ICCARM.CCOptLevel: 0
  AARM.ADefines: __SAM4S16C__; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: sam4s.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group inc
    ../../: decode.h encode.h main.h xplained.h
  group libraries
    ../../libboard_sam4s-ek/lib/: libboard_sam4s_ek_ewarm_dbg.a
    ../../libchip_sam4s/lib/: libchip_sam4s16_ewarm_dbg.a
  group src
    ../../: decode.c encode.c hijack_decode.c main.c xplained.c
