<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lightsense_single_tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lightsense_accumulated_tg.ewp</path>
  </project>
  <batchBuild/>
</workspace>


