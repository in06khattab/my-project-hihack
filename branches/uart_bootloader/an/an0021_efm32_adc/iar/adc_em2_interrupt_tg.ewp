# IAR project adc_em2_interrupt_tg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_em2_interrupt_tg.bin
  ILINK.IlinkOutputFile: adc_em2_interrupt_tg.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../emlib/src/: em_adc.c em_cmu.c em_emu.c em_int.c em_rtc.c em_system.c
  group Source
    ../: main_adc_em2_interrupt.c
