# IAR project hijack_efm32tg840.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\kits\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\EFM32TG_STK3300\config
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\TG840\EFM32TG840F32.icf
  ILINK.IlinkExtraOptions: ielftool my_input.out my_output.out --fill 0xFF;0–0xFF           --checksum __checksum:4,crc32;0–0xFF
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  group (top)
    ../tg840/: EFM32TG840F32.icf
  group BSP
    ../../../../common/bsp/: bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c vddcheck.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_system.c em_timer.c em_usart.c em_vcmp.c
  group Source
    ../tg840/: com.c com.h decode.c decode.h encode.c encode.h main.c main.h
